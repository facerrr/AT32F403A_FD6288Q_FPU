# Keil uVision project ATF403A_FD6288_FPU.uvprojx, settings and files
target App (6160000::V6.16::ARMCLANG)
  device: -AT32F403ACCT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.1
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ATF403A_FD6288_FPU +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: AT32F403ACCT7,USE_STDPERIPH_DRIVER
  c include: .\Code\Sys;.\Code\Bsp;.\Code\Lib\CMSIS;.\Code\Lib\inc;.\Code\middlewares\usbd_class\cdc;.\Code\middlewares\usbd_drivers\inc;.\Code\Foc
  memory RVCT4: ROM 0x8000000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Sys
    ./Code/Sys/: startup_at32f403a_407.s system_at32f403a_407.c main.c
  group Lib
    ./Code/Lib/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_dma.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usb.c at32f403a_407_crm.c
  group Bsp
    ./Code/Bsp/: adc_sample.c init_mcu.c isr.c spix.c timer.c usb.c
  group Foc
    ./Code/Foc/: filter.c flux.c motor_control.c pi_calc.c protection.c smo.c speed_set.c startup.c svpwm.c transform.c urs_config.c vf_control.c encoder.c mc_type.c stop_control.c calibration.c hfi.c
  group Usbd_Class
    ./Code/middlewares/usbd_class/cdc/: cdc_class.c cdc_desc.c
    ./Code/middlewares/usbd_drivers/src/: usbd_core.c usbd_int.c usbd_sdr.c
